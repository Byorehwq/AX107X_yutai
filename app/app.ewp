# IAR project app.ewp, settings and files
configuration AX207X_Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\
  ICC8051.CCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\; COMMON\; INC\; config\; api\; fm\; fat\; display\; display\theme_default\; display\led\; display\lcd\; task\; user\; mem\; module\; key\; startmusic\; spi\
  ICC8051.CCDefines: AX207X_TAG
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  postbuild: "$TARGET_DIR$\make.bat"
  XLINK.XclFile: lnk_base.xcl
configuration AX107X_Debug (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: AX107X_TAG
  A8051.ADefines: AX107X_TAG
  postbuild: $TARGET_DIR$\make.bat
configuration AX207X_UART_Debug (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\; COMMON\; INC\; config\; api\; fm\; fat\; display\; display\led\; display\lcd\; task\; user\; mem\; module\; module\kedir\; key\; startmusic\
  ICC8051.CCDefines: UART_DEBUG; AX207X_TAG
  A8051.ADefines: UART_DEBUG; AX207X_TAG
configuration AX107X_UART_Debug (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePaths: as above
  ICC8051.CCDefines: UART_DEBUG; AX107X_TAG
  A8051.ADefines: UART_DEBUG; AX107X_TAG
  group (top)
    ./: lnk_base.xcl main.c
  group config
    config/: config.c config.h config_ax1070_demo.h config_ax2070_demo.h config_default.h config_test.h
  group display
    display/: display.c display.h
  group display/led
    display/led/: led.c led_5c7s.c led_7p7s.c led_7p7s.h
  group display/theme_default
    display/theme_default/: theme_aux.c theme_fm.c theme_idle.c theme_music.c theme_poweroff.c theme_rtc.c theme_speaker.c theme_usbdev.c
  group fm
    fm/: api_fm.c bk1080.c kt0830.c qn8035.c qn8065.c rda5807p.c rtc6218.c si484x.c
  group key
    key/: adckey.c ir.c kedir.c kedir_all.c kedir_key.c kedir_key_ir.c kedir_key_led.c touch_key.c
  group mem
    mem/: mem.c mem_device.c mem_eeprom.c mem_internal.c mem_rtcram.c
  group module
    module/: clock.c dac.c device.c startmusic.c startmusic.h usb_tune.c
  group rtc
    rtc/: api_rtc.c
  group spi
    spi/: spi.c
  group startmusic
    startmusic/: startmusic.c
  group task
    task/: task.c task_alarm.c task_aux.c task_flash.c task_fm.c task_fmam_detect.c task_idle.c task_lowpower.c task_music.c task_poweroff.c task_rtc.c task_speaker.c task_usbdev.c
  group user
    user/: file_filter.c user_amux.c user_fat.c user_i2c.c user_init.c user_io.c user_key.c user_music.c user_setting.c user_spi.c user_usb.c user_usbdev.c
